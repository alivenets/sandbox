inherit setuptools3 native python3native
require python-attrs-native.inc
